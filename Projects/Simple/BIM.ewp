# IAR project BIM.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\SRC\bootloader\BIM; ..\..\SDK\CC254X\Components\hal\include; ..\..\SDK\CC254X\Components\hal\target\CC2540EB; ..\..\SDK\CC254X\Components\osal\include
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 2
  ICC8051.IccLang: 0
  XLINK.XclFile: bim_cc254x.xcl
configuration Release (8051, debug)
  as the first configuration, except:
  group APP
    ../../SRC/bootloader/BIM/: bim_ivec.s51 bim_main.c
  group HAL
    ../../SDK/CC254X/Components/hal/target/CC2540EB/: hal_flash.c
    ../../SDK/CC254X/Components/hal/include/: hal_flash.h
