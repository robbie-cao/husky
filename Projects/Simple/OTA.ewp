# IAR project OTA.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=FALSE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_LED=FALSE; HAL_LCD=FALSE; HAL_KEY=FALSE; HAL_I2C=TRUE; HAL_I2C_MASTER=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; LOG_LEVEL_DEBUG; OTA; FEATURE_OAD; OAD_KEEP_NV_PAGES; FEATURE_OAD_BIM; HAL_IMAGE_A
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\SDK\CC254X\Components\hal\include; ..\..\SDK\CC254X\Components\hal\target\CC2540EB; ..\..\SDK\CC254X\Components\osal\include; ..\..\SDK\CC254X\Components\services\saddr; ..\..\SDK\CC254X\Components\ble\include; ..\..\SDK\CC254X\Components\ble\controller\phy; ..\..\SDK\CC254X\Components\ble\controller\include; ..\..\SDK\CC254X\Components\ble\hci; ..\..\SDK\CC254X\Components\ble\host; ..\..\SDK\CC254X\Projects\ble\include; ..\..\SDK\CC254X\Projects\ble\common; ..\..\SDK\CC254X\Projects\ble\common\cc2540; ..\..\SDK\CC254X\Projects\ble\common\npi\npi_np; ..\..\SDK\CC254X\Projects\ble\Profiles\Roles; ..\..\SRC\inc; ..\..\SRC\utils; ..\..\SRC\drivers; ..\..\SRC\profiles\OAD; ..\..\SRC\profiles\SimpleProfile
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "OtaDebug\Exe\Simple_OTA"
  XLINK.XclFile: cc254x_f256_imgA.xcl
configuration Release (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=FALSE; HAL_DMA=TRUE; HAL_UART=TRUE; HAL_LED=FALSE; HAL_LCD=FALSE; HAL_KEY=FALSE; HAL_I2C=TRUE; HAL_I2C_MASTER=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; LOG_LEVEL_WARN; OTA; FEATURE_OAD; OAD_KEEP_NV_PAGES; FEATURE_OAD_BIM; HAL_IMAGE_A
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "OtaRelease\Exe\Simple_OTA"
  group APP/DRIVERS
    ../../SRC/drivers/: led.c led.h uart.c uart.h
  group APP/MAIN
    ../../SRC/simple/: main.c mainOsal.c mainTask.c
  group APP/PROFILES/OAD
    ../../SRC/profiles/OAD/: oad.h oad_target.c oad_target.h
  group APP/PROFILES/SIMPLE
    ../../SRC/profiles/SimpleProfile/: simpleGATTprofile.c simpleGATTprofile.h
  group APP/UTILS
    ../../SRC/utils/: log.c log.h util.c util.h
  group SDK/HAL/Common
    ../../SDK/CC254X/Components/hal/common/: hal_assert.c hal_drivers.c
  group SDK/HAL/Include
    ../../SDK/CC254X/Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../SDK/CC254X/Components/services/saddr/: saddr.h
  group SDK/HAL/Target/CC2540EB/Config
    ../../SDK/CC254X/Components/hal/target/CC2540EB/: hal_board_cfg.h
  group SDK/HAL/Target/CC2540EB/Drivers
    ../../SDK/CC254X/Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_crc.c hal_dma.c hal_flash.c hal_i2c.c hal_i2c.h hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group SDK/HAL/Target/CC2540EB/Includes
    ../../SDK/CC254X/Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_crc.h hal_dma.h hal_mcu.h hal_types.h
  group SDK/INCLUDE
    ../../SDK/CC254X/Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../SDK/CC254X/Components/ble/host/: linkdb.h
    ../../SDK/CC254X/Components/ble/controller/include/: ll.h phy.h
    ../../SDK/CC254X/Projects/ble/common/npi/npi_np/: npi.h
  group SDK/LIB
    ../../SDK/CC254X/Projects/ble/Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    ../../SDK/CC254X/Projects/ble/Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group SDK/NPI
    ../../SDK/CC254X/Projects/ble/common/npi/npi_np/: npi.c
  group SDK/OSAL
    ../../SDK/CC254X/Components/ble/include/: bcomdef.h
    ../../SDK/CC254X/Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../SDK/CC254X/Components/osal/mcu/cc2540/: osal_snv.c
  group SDK/PROFILES/ROLES
    ../../SDK/CC254X/Projects/ble/Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h peripheralBroadcaster.c peripheralBroadcaster.h
    ../../SDK/CC254X/Projects/ble/Include/: gattservapp.h
  group SDK/PROFILES/UUID
    ../../SDK/CC254X/Projects/ble/Include/: gapgattserver.h
    ../../SDK/CC254X/Components/ble/host/: gatt_uuid.c
  group SDK/TOOLS
    ./: buildComponents.cfg buildConfig.cfg
    ../../SDK/CC254X/Projects/ble/common/cc2540/: OnBoard.c OnBoard.h
